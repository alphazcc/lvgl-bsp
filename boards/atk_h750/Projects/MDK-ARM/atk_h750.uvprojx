# Keil uVision project atk_h750.uvprojx, settings and files
target LVGL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: atk_h750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32H750xx
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\..\Drivers\CMSIS\Include;..\..\Middlewares;..\..\Drivers;..\..\..\..\lvgl;..\..\..\..\lvgl\lvgl;..\..\..\..\lvgl\lvgl\src;..\..\Middlewares\GUI\lvgl\examples\porting;..\..\..\..\lvgl\lvgl\demos\stress
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\User\SCRIPT\qspi_code.scf.scf
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group User
    ../../User/: main.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/MPU/: mpu.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/TOUCH/: touch.c ctiic.c ft5206.c gt9xxx.c
    ../../Drivers/BSP/TIMER/: btim.c
  group Readme
    ../../: readme.txt
  group lvgl/example/porting
    ../../Middlewares/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group lvgl/src/core
    ../../../../lvgl/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl/src/draw
    ../../../../lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../../../../lvgl/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl/src/extra
    ../../../../lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../../../lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../../../lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../../../lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../../../lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../../../lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../../../lvgl/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../../../lvgl/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../../../lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../../../lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../../../lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../../../lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../../../lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../../../lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../../../lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../../../lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../lvgl/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../lvgl/lvgl/src/extra/widgets/led/: lv_led.c
    ../../../../lvgl/lvgl/src/extra/widgets/list/: lv_list.c
    ../../../../lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../../../lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../../../lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../lvgl/lvgl/src/extra/widgets/span/: lv_span.c
    ../../../../lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../lvgl/lvgl/src/extra/widgets/win/: lv_win.c
    ../../../../lvgl/lvgl/src/extra/: lv_extra.c
  group lvgl/src/font
    ../../../../lvgl/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl/src/gpu
    ../../../../lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../../../lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group lvgl/src/hal
    ../../../../lvgl/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl/src/misc
    ../../../../lvgl/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl/src/widgets
    ../../../../lvgl/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl/demos/stress
    ../../../../lvgl/lvgl/demos/stress/: lv_demo_stress.c
